# Keil uVision project Project.uvproj, settings and files
target 828C TEST CLOCK (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(11059200)
  output: Bridge828C_TEST_CLOCK +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: BRIDGE_BUILD_TEST
  c include: .\User;.\App;.\System;.\Public;.\Control
  group User
    ./User/: main.c STARTUP.A51
  group App
    ./App/: app_comm.c app_comm.h
  group System
    ./System/: System.c System.h Uart1.c Uart1.h Uart2.c Uart2.h
  group Public
    ./Public/: STC12C5A60S2.h project_types.h board_config.h Public_cfg.h
  group Control
    ./Control/: input_control.c input_control.h
target 828C ISP MEASURED (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(11059200)
  output: Bridge828C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\App;.\System;.\Public;.\Control
